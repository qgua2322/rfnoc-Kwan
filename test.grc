<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>latencytest</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>address</value></param>
<param><key>value</key><value>-(0xffffffff)/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>context_len</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_bins</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>p_offset</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>qx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>qy</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>784000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_w</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>args</value></param>
</block>
<block>
<key>Kwan_latencytest</key>
<param><key>id</key><value>Kwan_latencytest_0</value></param>
<param><key>otw</key><value>u8</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_latencytest</value></param>
<param><key>grvlen</key><value>8</value></param>
<param><key>type</key><value>u8</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>args</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/phwl/rfnoc/src/rfnoc-Kwan/out.bin</value></param>
<param><key>type</key><value>int</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/phwl/rfnoc/src/rfnoc-Kwan/test_out.bin</value></param>
<param><key>type</key><value>int</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/phwl/rfnoc/src/rfnoc-Kwan/test_in.bin</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>int</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0</value></param>
<param><key>otw</key><value>u8</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_fifo_loopback</value></param>
<param><key>grvlen</key><value>8</value></param>
<param><key>type</key><value>u8</value></param>
</block>
<connection><source_block_id>Kwan_latencytest_0</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0</source_block_id><sink_block_id>Kwan_latencytest_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
